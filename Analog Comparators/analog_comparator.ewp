# IAR project analog_comparator.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PGE TexasInstruments TM4C123GH6PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PGE; TARGET_IS_TM4C123_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..\..\..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..; ..\..\..\..
  OBJCOPY.OOCOutputFile: analog_comparator.bin
  ILINK.IlinkOutputFile: analog_comparator.out
  ILINK.IlinkIcfFile: analog_comparator.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
    ../../../../grlib/ewarm/Exe/: grlib.a
  group Source
    ../drivers/: cfal96x64x16.c
    ./: startup_ewarm.c analog_comparator.c
